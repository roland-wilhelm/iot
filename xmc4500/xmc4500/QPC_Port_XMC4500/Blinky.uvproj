# Keil uVision project Blinky.uvproj, settings and files
target TracePort Trace (ARM-ADS)
  device: XMC4500-1024 Infineon
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x0C000000-0x0C0FFFFF) IROM2(0x08000000-0x080FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ NOASSERT   QF_TICK QK
  c include: C:\qm\qpc\qep\source;C:\qm\qpc\qf\source;C:\qm\qpc\include;C:\qm\qpc\ports\arm7tdmi\Keil\inc
  memory RVCT4: ROM 0xc000000 size 0x100000
  memory RVCT5: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ./: startup_XMC4500.s System_XMC4500.c
  group Source Files
    ./: ADC.c LED.c Serial.c Retarget.c IRQ.c Blinky.c qk_port.c bsp.c base_ao.c Hex_O_Pan_Send.c
  group Documentation
    ./: Abstract.txt
  group qm_qep
    C:/qm/qpc/qep/source/: qep.c qfsm_dis.c qfsm_ini.c qhsm_dis.c qhsm_in.c qhsm_ini.c qhsm_top.c
  group qm_qf
    C:/qm/qpc/qf/source/: qte_rarm.c qa_defer.c qa_fifo.c qa_get_.c qa_lifo.c qa_sub.c qa_usub.c qa_usuba.c qeq_fifo.c qeq_get.c qeq_init.c qeq_lifo.c qf_act.c qf_gc.c qf_log2.c qf_new.c qf_pool.c qf_psini.c qf_pspub.c qf_pwr2.c qf_tick.c qmp_get.c qmp_init.c qmp_put.c qte_arm.c qte_ctor.c qte_darm.c
  group qm_qk
    C:/qm/qpc/qk/source/: qk.c qk_ext.c qk_mutex.c qk_sched.c
target TracePort IntructionTrace (ARM-ADS)
  device: XMC4500-1024 Infineon
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ
  memory RVCT4: ROM 0xc000000 size 0x100000
  memory RVCT5: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
