# Keil uVision project sam7xqm.uvproj, settings and files
target uip_ao (ARM-ADS)
  device: AT91SAM7XC512 Atmel
  cpu: IRAM(0x200000-0x21FFFF) IROM(0x100000-0x17FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: sam7xqm
  c flags: Optim=1
  c define: at91sam7x512  NOFPUT  NOASSERT  STDIO_NOT_DEFINE  QF_TICK QK
  c include: ..\..\at91sam7\AT91Lib\peripherals;..\..\at91sam7\includes;..\..\at91sam7\AT91Lib\;..\..\at91sam7\AT91Lib\utility;..\..\at91sam7\AT91Lib\peripherals\emac;..\..\..\qm\qpc\qep\source;..\..\..\qm\qpc\qf\source;..\..\..\qm\qpc\include;..\..\..\qm\qpc\ports\arm7tdmi\Keil\inc;.\ooipv6;.\app;.\net;..\..\at91sam7\network\phy_mac\phy_eth
  asm misc: --predefine "REMAP SETL {TRUE}"  --predefine "RAM_INTVEC SETL {TRUE}"
  memory RVCT4: ROM 0x200000 size 0x7fff
  memory RVCT9: RAM 0x208000 size 0x7fff
  link misc: --entry 0x200000
  group at91lib
    ../../at91sam7/AT91Lib/peripherals/dbgu/: dbgu.c
    ../../at91sam7/AT91Lib/peripherals/aic/: aic.c
    ../../at91sam7/AT91Lib/peripherals/pio/: pio.c pio_it.c
    ../../at91sam7/AT91Lib/peripherals/pit/: pit.c
    ../../at91sam7/AT91Lib/peripherals/pmc/: pmc.c
    ../../at91sam7/AT91Lib/peripherals/tc/: tc.c
    ../../at91sam7/AT91Lib/peripherals/emac/: emac.c
    ../../at91sam7/AT91Lib/peripherals/rstc/: rstc.c
  group bsp
    ../../at91sam7/bsp/: bsp_at91.c
  group startup
    ../../at91sam7/startup/: board_lowlevel.c critical_sec.s SAM7.s swi_interrup.s
  group app
    ./app/: uip_ao.c bsp_uip_ao.c qk_port.c
    ./app/ethernet_ao/: ethernet_ao.c
  group retarget
    ../../at91sam7/retarget/: retarget.c
  group at91lib_utilites
    ../../at91sam7/AT91Lib/utility/: led.c
  group qm_qep
    C:/qm/qpc/qep/source/: qep.c qfsm_dis.c qfsm_ini.c qhsm_dis.c qhsm_in.c qhsm_ini.c qhsm_top.c
  group qm_qf
    C:/qm/qpc/qf/source/: qa_defer.c qa_fifo.c qa_get_.c qa_lifo.c qa_sub.c qa_usub.c qa_usuba.c qeq_fifo.c qeq_get.c qeq_init.c qeq_lifo.c qf_act.c qf_gc.c qf_log2.c qf_new.c qf_pool.c qf_psini.c qf_pspub.c qf_pwr2.c qf_tick.c qmp_get.c qmp_init.c qmp_put.c qte_arm.c qte_ctor.c qte_darm.c qte_rarm.c
  group phy_emac
    ./app/ethernet_ao/: ethernet.c physical_dp83848.c ethernet_isr.c
    ./app/: init_ipv4.c
    ../../at91sam7/network/phy_mac/phy_eth/: DP83848.c
  group ooipv6
    ./ooipv6/: uip-nd6.c uip6.c uip-icmp6.c neighbor_ao.c
  group qk
    C:/qm/qpc/qk/source/: qk.c qk_ext.c qk_mutex.c qk_sched.c
