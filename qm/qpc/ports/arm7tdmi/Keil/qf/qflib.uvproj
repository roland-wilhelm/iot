# Keil uVision project qflib.uvproj, settings and files
target qflib (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: qflib (library)
  c flags: Optim=1
  c include: ..\..\inc;..\..\..\..\qf\source;..\..\..\..\include
  group sources
    ../../../../qf/source/: qa_defer.c qa_fifo.c qa_get_.c qa_lifo.c qa_sub.c qa_usub.c qa_usuba.c qeq_fifo.c qeq_get.c qeq_init.c qeq_lifo.c qf_act.c qf_gc.c qf_log2.c qf_new.c qf_pool.c qf_psini.c qf_pspub.c qf_pwr2.c qf_tick.c qmp_get.c qmp_init.c qmp_put.c qte_arm.c qte_ctor.c qte_darm.c qte_rarm.c qvanilla.c
