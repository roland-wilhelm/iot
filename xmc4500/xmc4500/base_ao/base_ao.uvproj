# Keil uVision project base_ao.uvproj, settings and files
target base_ao (ARM-ADS)
  device: XMC4500-1024 Infineon
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x0C000000-0x0C0FFFFF) IROM2(0x08000000-0x080FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: base_ao
  c flags: Optim=1
  c define: __ADC_IRQ  QF_TICK  QK  CORTEX
  c include: ..\..\4500relax\drivers;..\qmbsp;..\..\..\qm\qpc\include;..\..\..\qm\qpc\ports\arm-cortex\qk\keil;..\..\..\qm\qpc\qep\source;..\..\..\qm\qpc\qf\source
  memory RVCT4: ROM 0x10000000 size 0x10000
  memory RVCT5: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../../4500relax/startup/: svc_interrupt.c System_XMC4500.c startup_XMC4500.s SVC_Table.s
  group retarget
    ../../4500relax/retarget/: Retarget.c
  group drivers
    ../../4500relax/drivers/: ADC.c button.c IRQ.c LED.c Serial.c ETH_XMC45xx.c
    ./Network/: uip.h
  group app
    ../qmbsp/: qmbsp.c
    C:/qm/qpc/ports/arm-cortex/qk/keil/: qk_port.c
    ./Network/: uip_ao.c ethernet_ao.c
  group qep
    C:/qm/qpc/qep/source/: qep.c qfsm_dis.c qfsm_ini.c qhsm_dis.c qhsm_in.c qhsm_ini.c qhsm_top.c
  group qf
    C:/qm/qpc/qf/source/: qa_defer.c qa_fifo.c qa_get_.c qa_lifo.c qa_sub.c qa_usub.c qa_usuba.c qeq_fifo.c qeq_get.c qeq_init.c qeq_lifo.c qf_act.c qf_gc.c qf_log2.c qf_new.c qf_pool.c qf_psini.c qf_pspub.c qf_pwr2.c qf_tick.c qmp_get.c qmp_init.c qmp_put.c qte_arm.c qte_ctor.c qte_darm.c qte_rarm.c
  group qk
    C:/qm/qpc/qk/source/: qk.c qk_ext.c qk_mutex.c qk_sched.c
  group ooipv6
    ./Network/: uip.c init_ipv4.c uip-nd6.c uip-icmp6.c neighbor_ao.c uip6.c udp_socket.c md5.c customHeap.c
