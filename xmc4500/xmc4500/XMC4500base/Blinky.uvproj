# Keil uVision project Blinky.uvproj, settings and files
target XMC4500 PSRAM (ARM-ADS)
  device: XMC4500-1024 Infineon
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x0C000000-0x0C0FFFFF) IROM2(0x08000000-0x080FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ __DBG_ITM  __KEIL__
  memory RVCT4: ROM 0x10000000 size 0x10000
  memory RVCT5: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ./: startup_XMC4500.s system_XMC4500.c
  group Source Files
    ./: ADC.c LED.c Serial.c Retarget.c IRQ.c Blinky.c eth_main.c eth_inf.c
  group Documentation
    ./: Abstract.txt
  group drivers
    ../../4500relax/drivers/ETHERNET_V2.4/Src/: eth_iil_dmur.c eth_iil_dmut.c eth_iil_mac.c eth_iil_rb.c eth_iil_tb.c
    ./: sys_gpio.c
target XMC4500 Flash (ARM-ADS)
  device: XMC4500-1024 Infineon
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ
  memory RVCT4: ROM 0xc000000 size 0x100000
  memory RVCT5: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
target XMC4500 cached Flash (ARM-ADS)
  device: XMC4500-1024 Infineon
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ
  memory RVCT4: ROM 0xc000000 size 0x100000
  memory RVCT5: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
