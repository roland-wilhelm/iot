# Keil uVision project qep.uvproj, settings and files
target qeplib (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: qep (library)
  c flags: Optim=1
  c include: ..\..\inc;..\..\..\..\include;..\..\..\..\qep\source
  group QEP
    ../../../../qep/source/: qep.c qfsm_dis.c qfsm_ini.c qhsm_dis.c qhsm_in.c qhsm_ini.c qhsm_top.c
